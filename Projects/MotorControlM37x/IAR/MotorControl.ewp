# IAR project MotorControl.ewp, settings and files
configuration Debug - HitexM370 (ARM, debug)
  General.OGChipSelectEditMenu: TMPM370FYDFG Toshiba TMPM370FYDFG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_HITEX_M370; __TMPM_370__; DEBUG
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ; ..; ..\..\..\Source\Motors; ..\..\..\Source\Board\CPU_Board\HitexM370\include; ..\..\..\Source\Board\Powerboard; ..\..\..\Source\M37xHWGeneric\include; ..\..\..\Source\M37xSWModules\include; ..\..\..\Source\FreeRTOS\Source\include; ..\..\..\Source\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\Source\CMSIS\TX03_CMSIS; ..\..\..\Source\CMSIS\TX03_Periph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: MotorControl.srec
  ILINK.IlinkOutputFile: MotorControl.out
  ILINK.IlinkIcfFile: M370.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release - HitexM370 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_HITEX_M370; __TMPM_370__
configuration Debug - M374STK (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM374FWUG Toshiba TMPM374FWUG
  ICCARM.CCDefines: BOARD_M374STK; __TMPM_374__; DEBUG; _IARCMSIS_
  ICCARM.CCIncludePath2: ; ..; ..\..\..\Source\Motors; ..\..\..\Source\Board\Baseboard\M374Baseboard\include; ..\..\..\Source\Board\Powerboard; ..\..\..\Source\M37xHWGeneric\include; ..\..\..\Source\M37xSWModules\include; ..\..\..\Source\FreeRTOS\Source\include; ..\..\..\Source\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\Source\CMSIS\TX03_CMSIS; ..\..\..\Source\CMSIS\TX03_Periph_Driver\inc
  OBJCOPY.OOCOutputFile: MotorControl.bin
  ILINK.IlinkIcfFile: M372_3_4.icf
configuration Release - M374STK (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM374FWUG Toshiba TMPM374FWUG
  ICCARM.CCDefines: BOARD_M374STK; __TMPM_374__
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: M372_3_4.icf
configuration Debug - M372STK (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM372FWUG Toshiba TMPM372FWUG
  ICCARM.CCDefines: BOARD_M372STK; __TMPM_372__; DEBUG; _IARCMSIS_
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: M372_3_4.icf
configuration Release - M372STK (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM372FWUG Toshiba TMPM372FWUG
  ICCARM.CCDefines: BOARD_M372STK; __TMPM_372__
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: M372_3_4.icf
configuration Debug - M37Sigma (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM373FWDUG Toshiba TMPM373FWDUG
  ICCARM.CCDefines: BOARD_M37SIGMA; __TMPM_373__; DEBUG; _IARCMSIS_; USE_I2C_MASTER; USE_RGB_LED; USE_EXTERNAL_SPEED_CONTROL; USE_RW_BOARD_SETTINGS
  ICCARM.CCIncludePath2: ; ..; ..\..\..\Source\Motors; ..\..\..\Source\Board\CPU_Board\M37Sigma\include; ..\..\..\Source\Board\Powerboard; ..\..\..\Source\M37xHWGeneric\include; ..\..\..\Source\M37xSWModules\include; ..\..\..\Source\FreeRTOS\Source\include; ..\..\..\Source\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\Source\CMSIS\TX03_CMSIS; ..\..\..\Source\CMSIS\TX03_Periph_Driver\inc
  OBJCOPY.OOCOutputFile: M37Sigma.bin
  ILINK.IlinkIcfFile: M372_3_4.icf
configuration Release - M37Sigma (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM373FWDUG Toshiba TMPM373FWDUG
  ICCARM.CCDefines: BOARD_M37SIGMA; __TMPM_373__; _IARCMSIS_; USE_I2C_MASTER; USE_RGB_LED; USE_EXTERNAL_SPEED_CONTROL; USE_RW_BOARD_SETTINGS
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: M37Sigma.bin
  ILINK.IlinkIcfFile: M372_3_4.icf
  group (top)
    ../: config.h FreeRTOSConfig.h main.c user_config.h
  group Board/Baseboard/M374Baseboard
    ../../../Source/Board/Baseboard/M374Baseboard/: m374stk_board.c m374stk_can.c m374stk_eeprom.c m374stk_gain.c m374stk_led.c m374stk_pga.c m374stk_spi_device.c
  group Board/Baseboard/M374Baseboard/include
    ../../../Source/Board/Baseboard/M374Baseboard/include/: m374stk_board.h m374stk_can.h m374stk_gain.h m374stk_led.h m374stk_pga.h m374stk_spi_device.h
  group Board/CPU Board/HitexM370
    ../../../Source/Board/CPU_Board/HitexM370/: hitex_m370_board.c hitex_m370_eeprom.c hitex_m370_gain.c hitex_m370_keypad.c hitex_m370_lcd.c hitex_m370_led.c hitex_m370_spi_device.c hitex_m370_ui.c
  group Board/CPU Board/HitexM370/include
    ../../../Source/Board/CPU_Board/HitexM370/include/: hitex_m370_board.h hitex_m370_gain.h hitex_m370_keypad.h hitex_m370_lcd.h hitex_m370_led.h hitex_m370_spi_device.h hitex_m370_ui.h
  group Board/CPU Board/M37Sigma
    ../../../Source/Board/CPU_Board/M37Sigma/: m37sigma_board.c m37sigma_gain.c m37sigma_led.c m37sigma_rgb_led.c
  group Board/CPU Board/M37Sigma/include
    ../../../Source/Board/CPU_Board/M37Sigma/include/: m37sigma_board.h m37sigma_gain.h m37sigma_led.h m37sigma_rgb_led.h
  group Board/Powerboard
    ../../../Source/Board/Powerboard/: hitex_m370_pwr_hv.h hitex_m370_pwr_lv.h m374pwr_hv.h m374pwr_lv.h m37Sigma_pwr.h m37x_ipm_power_ver1.h m37x_ipm_power_ver2.h powerboard_skeleton.h pwr_undefine.h super_mini_dip.h temperature_measure_table.h
  group CMSIS
    ../../../Source/CMSIS/TX03_CMSIS/: core_cm3.c
  group CMSIS/Periphrial/Include
    ../../../Source/CMSIS/TX03_Periph_Driver/inc/: tx03_common.h
  group CMSIS/Periphrial/Include/tmpm370
    ../../../Source/CMSIS/TX03_Periph_Driver/inc/: tmpm370_adc.h tmpm370_cg.h tmpm370_fc.h tmpm370_gpio.h tmpm370_ofd.h tmpm370_tmrb.h tmpm370_uart.h tmpm370_vltd.h tmpm370_wdt.h
  group CMSIS/Periphrial/Include/tmpm372
    ../../../Source/CMSIS/TX03_Periph_Driver/inc/: tmpm372_adc.h tmpm372_cg.h tmpm372_fc.h tmpm372_gpio.h tmpm372_ofd.h tmpm372_tmrb.h tmpm372_uart.h tmpm372_vltd.h tmpm372_wdt.h
  group CMSIS/Periphrial/Include/tmpm373
    ../../../Source/CMSIS/TX03_Periph_Driver/inc/: tmpm373_adc.h tmpm373_cg.h tmpm373_fc.h tmpm373_gpio.h tmpm373_ofd.h tmpm373_tmrb.h tmpm373_uart.h tmpm373_vltd.h tmpm373_wdt.h
  group CMSIS/Periphrial/Include/tmpm374
    ../../../Source/CMSIS/TX03_Periph_Driver/inc/: tmpm374_adc.h tmpm374_cg.h tmpm374_fc.h tmpm374_gpio.h tmpm374_ofd.h tmpm374_tmrb.h tmpm374_uart.h tmpm374_vltd.h tmpm374_wdt.h
  group CMSIS/Periphrial/Source/tmpm370
    ../../../Source/CMSIS/TX03_Periph_Driver/src/: tmpm370_adc.c tmpm370_cg.c tmpm370_fc.c tmpm370_gpio.c tmpm370_ofd.c tmpm370_tmrb.c tmpm370_uart.c tmpm370_vltd.c tmpm370_wdt.c
  group CMSIS/Periphrial/Source/tmpm372
    ../../../Source/CMSIS/TX03_Periph_Driver/src/: tmpm372_adc.c tmpm372_cg.c tmpm372_fc.c tmpm372_gpio.c tmpm372_ofd.c tmpm372_tmrb.c tmpm372_uart.c tmpm372_vltd.c tmpm372_wdt.c
  group CMSIS/Periphrial/Source/tmpm373
    ../../../Source/CMSIS/TX03_Periph_Driver/src/: tmpm373_adc.c tmpm373_cg.c tmpm373_fc.c tmpm373_gpio.c tmpm373_ofd.c tmpm373_tmrb.c tmpm373_uart.c tmpm373_vltd.c tmpm373_wdt.c
  group CMSIS/Periphrial/Source/tmpm374
    ../../../Source/CMSIS/TX03_Periph_Driver/src/: tmpm374_adc.c tmpm374_cg.c tmpm374_fc.c tmpm374_gpio.c tmpm374_ofd.c tmpm374_tmrb.c tmpm374_uart.c tmpm374_vltd.c tmpm374_wdt.c
  group CMSIS/tmpm370
    ../../../Source/CMSIS/TX03_CMSIS/startup/iar/: startup_TMPM370.s
    ../../../Source/CMSIS/TX03_CMSIS/: system_TMPM370.c system_TMPM370.h TMPM370.h
  group CMSIS/tmpm372
    ../../../Source/CMSIS/TX03_CMSIS/startup/iar/: startup_TMPM372.s
    ../../../Source/CMSIS/TX03_CMSIS/: system_TMPM372.c system_TMPM372.h TMPM372.h
  group CMSIS/tmpm373
    ../../../Source/CMSIS/TX03_CMSIS/startup/iar/: startup_TMPM373.s
    ../../../Source/CMSIS/TX03_CMSIS/: system_TMPM373.c system_TMPM373.h TMPM373.h
  group CMSIS/tmpm374
    ../../../Source/CMSIS/TX03_CMSIS/startup/iar/: startup_TMPM374.s
    ../../../Source/CMSIS/TX03_CMSIS/: system_TMPM374.c system_TMPM374.h TMPM374.h
  group FreeRTOS
    ../../../Source/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../Source/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Source/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOS/Include
    ../../../Source/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../Source/FreeRTOS/Source/portable/IAR/ARM_CM3/: portmacro.h
  group M37xHWGeneric
    ../../../Source/M37xHWGeneric/: adc.c amp_cmp.c encoder.c mcp2515.c pmd.c spi.c ve.c
  group M37xHWGeneric/include
    ../../../Source/M37xHWGeneric/include/: adc.h amp_cmp.h eeprom.h encoder.h MCP2515.h motorctrl.h pmd.h spi.h ve.h
  group M37xSWModules
    ../../../Source/M37xSWModules/: action.c board.c compiled_in_motor.c config_storage.c crc8.c debug.c dso.c external_speed_control.c hsdso.c hv_serial_communication.c i2c_master_bitbanging.c load_statistics.c protocol.c stall_detect.c storage_eeprom.c storage_flash.c temperature_control.c turn_control.c user_callbacks.c
  group M37xSWModules/Include
    ../../../Source/M37xSWModules/include/: action.h board.h compiled_in_motor.h config_storage.h crc8.h debug.h dso.h external_speed_control.h hsdso.h hv_serial_communication.h i2c_master_bitbanging.h load_statistics.h protocol.h stall_detect.h storage_backend.h temperature_control.h turn_control.h user_callbacks.h
  group Motors
    ../../../Source/Motors/: motor_define_Dunker_BG_42x15.h motor_define_Gefeg_ECs-7140_HV.h motor_define_Maxxon_EC.h motor_define_Nanotec_DB42S01@24V.h motor_define_Nanotec_DB42S03.h motor_define_Nanotec_DB42S03@HitexChannel0.h motor_define_Scorpion_3014-830KV.h motor_define_Shinano_DR38312.h motor_define_Shinano_PMBA-200FK_HV.h motor_undefine.h
