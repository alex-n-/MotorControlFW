# Keil uVision project MotorControl.uvproj, settings and files
target Debug - Hitex370 (ARM-ADS)
  device: TMPM370FYDFG Toshiba
  cpu: IRAM(0x20000000-0x200027FF) IROM(0-0x0003FFFF) CLOCK(10000000) CPUTYPE("Cortex-M3")
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_HITEX_M370 __KEIL__ DEBUG __DBG_ITM __TMPM_370__
  c include: ..\..\..\Source\CMSIS\TX03_Periph_Driver\inc;..\..\..\Source\FreeRTOS\Source\include;..\..\..\Source\M37xHWGeneric\include;..\..\..\Source\M37xSWModules\include;..\..\..\Source\Motors;..\..\MotorControlM37x;..\..\..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Source\CMSIS\TX03_CMSIS;..\..\..\Source\Board\CPU_Board\HitexM370\include;..\..\..\Source\Board\Powerboard
  asm define: BOARD_HITEX_M370
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group M374Baseboard
    ../../../Source/Board/Baseboard/M374Baseboard/: m374stk_spi_device.c m374stk_board.c m374stk_can.c m374stk_eeprom.c m374stk_gain.c m374stk_led.c m374stk_pga.c
  group M374Baseboard_include
    ../../../Source/Board/Baseboard/M374Baseboard/include/: m374stk_spi_device.h m374stk_board.h m374stk_can.h m374stk_gain.h m374stk_led.h m374stk_pga.h
  group M37Sigma_CPUBoard
    ../../../Source/Board/CPU_Board/M37Sigma/: m37sigma_rgb_led.c m37sigma_board.c m37sigma_gain.c m37sigma_led.c
  group M37Sigma_CPUBoard_include
    ../../../Source/Board/CPU_Board/M37Sigma/include/: m37sigma_rgb_led.h m37sigma_board.h m37sigma_gain.h m37sigma_led.h
  group HitexM370_CPUBoard
    ../../../Source/Board/CPU_Board/HitexM370/: hitex_m370_ui.c hitex_m370_board.c hitex_m370_eeprom.c hitex_m370_gain.c hitex_m370_keypad.c hitex_m370_lcd.c hitex_m370_led.c hitex_m370_spi_device.c
  group HitexM370CPUBoard_include
    ../../../Source/Board/CPU_Board/HitexM370/include/: hitex_m370_ui.h hitex_m370_board.h hitex_m370_gain.h hitex_m370_keypad.h hitex_m370_lcd.h hitex_m370_led.h hitex_m370_spi_device.h
  group Powerboard
    ../../../Source/Board/Powerboard/: pwr_undefine.h hitex_m370_pwr_hv.h hitex_m370_pwr_lv.h m37Sigma_pwr.h m37x_ipm_power_ver1.h m37x_ipm_power_ver2.h m374pwr_hv.h m374pwr_lv.h temperature_measure_table.h
  group CMSIS
    ../../../Source/CMSIS/TX03_CMSIS/startup/arm/: startup_TMPM370.s startup_TMPM374.s startup_TMPM372.s startup_TMPM373.s
    ../../../Source/CMSIS/TX03_CMSIS/: system_TMPM370.c system_TMPM374.c core_cm3.c system_TMPM372.c system_TMPM373.c
    ../../../Source/CMSIS/TX03_Periph_Driver/src/: tmpm370_adc.c tmpm370_cg.c tmpm370_fc.c tmpm370_gpio.c tmpm370_ofd.c tmpm370_tmrb.c tmpm370_uart.c tmpm370_vltd.c tmpm370_wdt.c tmpm374_adc.c tmpm374_cg.c tmpm374_fc.c tmpm374_gpio.c tmpm374_ofd.c tmpm374_tmrb.c tmpm374_uart.c tmpm374_vltd.c tmpm374_wdt.c tmpm372_wdt.c tmpm372_adc.c tmpm372_cg.c tmpm372_fc.c tmpm372_gpio.c tmpm372_ofd.c tmpm372_tmrb.c tmpm372_uart.c tmpm372_vltd.c tmpm373_vltd.c tmpm373_wdt.c tmpm373_adc.c tmpm373_cg.c tmpm373_fc.c tmpm373_gpio.c tmpm373_ofd.c tmpm373_tmrb.c tmpm373_uart.c
  group CMSIS_include
    ../../../Source/CMSIS/TX03_CMSIS/: TMPM374.h system_TMPM370.h system_TMPM374.h TMPM370.h TMPM372.h system_TMPM372.h TMPM373.h system_TMPM373.h
    ../../../Source/CMSIS/TX03_Periph_Driver/inc/: tmpm374_adc.h tmpm374_cg.h tmpm374_fc.h tmpm374_gpio.h tmpm374_ofd.h tmpm374_tmrb.h tmpm374_uart.h tmpm374_vltd.h tmpm374_wdt.h tx03_common.h tmpm370_adc.h tmpm370_cg.h tmpm370_fc.h tmpm370_gpio.h tmpm370_ofd.h tmpm370_tmrb.h tmpm370_uart.h tmpm370_vltd.h tmpm370_wdt.h tmpm372_wdt.h tmpm372_adc.h tmpm372_cg.h tmpm372_fc.h tmpm372_gpio.h tmpm372_ofd.h tmpm372_tmrb.h tmpm372_uart.h tmpm372_vltd.h tmpm373_wdt.h tmpm373_adc.h tmpm373_cg.h tmpm373_fc.h tmpm373_gpio.h tmpm373_ofd.h tmpm373_tmrb.h tmpm373_uart.h tmpm373_vltd.h
  group FreeRTOS
    ../../../Source/FreeRTOS/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../../Source/FreeRTOS/Source/portable/RVDS/ARM_CM3/: portmacro.h port.c
    ../../../Source/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group FreeRTOS_include
    ../../../Source/FreeRTOS/Source/include/: timers.h croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
  group M37xHWGeneric
    ../../../Source/M37xHWGeneric/: ve.c adc.c amp_cmp.c encoder.c mcp2515.c pmd.c spi.c
  group M37xHWGeneric_include
    ../../../Source/M37xHWGeneric/include/: ve.h adc.h amp_cmp.h eeprom.h encoder.h MCP2515.h motorctrl.h pmd.h spi.h
  group M37xSWModules
    ../../../Source/M37xSWModules/: storage_flash.c action.c board.c compiled_in_motor.c crc8.c debug.c dso.c load_statistics.c protocol.c storage_eeprom.c hsdso.c stall_detect.c turn_control.c hv_serial_communication.c user_callbacks.c config_storage.c external_speed_control.c i2c_master_bitbanging.c temperature_control.c
  group M37xSWModules_include
    ../../../Source/M37xSWModules/include/: storage_eeprom.h action.h board.h compiled_in_motor.h crc8.h debug.h dso.h load_statistics.h protocol.h hsdso.h stall_detect.h turn_control.h hv_serial_communication.h user_callbacks.h storage_backend.h config_storage.h i2c_master_bitbanging.h external_speed_control.h temperature_control.h
  group Motors
    ../../../Source/Motors/: motor_undefine.h motor_define_Dunker_BG_42x15.h motor_define_Maxxon_EC.h motor_define_Nanotec_DB42S03.h motor_define_Nanotec_DB42S03@HitexChannel0.h motor_define_Scorpion_3014-830KV.h motor_define_Shinano_DR38312.h motor_define_Nanotec_DB42S01@24V.h motor_define_Gefeg_ECs-7140_HV.h motor_define_Shinano_PMBA-200FK_HV.h
  group KeilDebug
    ./: Serial.h Retarget.c Serial.c
  group MotorControl
    ../: main.c config.h FreeRTOSConfig.h user_config.h
target Release - Hitex370 (ARM-ADS)
  device: TMPM370FYDFG Toshiba
  cpu: as above
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_HITEX_M370 __KEIL__ __TMPM_370__
  c include: as above
  asm define: BOARD_HITEX_M370
  asm include: ..\..\..\Source\Board\HitexM370\include;..\..\..\Source\CMSIS\TX03_Periph_Driver\inc;..\..\..\Source\FreeRTOS\Source\include;..\..\..\Source\M37xHWGeneric\include;..\..\..\Source\M37xSWModules\include;..\..\..\Source\Motors;..\..\MotorControlM37x;..\..\..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Source\CMSIS\TX03_CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Debug - M374STK (ARM-ADS)
  device: TMPM374FWUG Toshiba
  cpu: IRAM(0x20000000-0x200017FF) IROM(0-0x0001FFFF) CLOCK(10000000) CPUTYPE("Cortex-M3")
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_M374STK __KEIL__ DEBUG __DBG_ITM __TMPM_374__
  c include: ..\..\..\Source\Board\Baseboard\M374Baseboard\include;..\..\..\Source\CMSIS\TX03_Periph_Driver\inc;..\..\..\Source\FreeRTOS\Source\include;..\..\..\Source\M37xHWGeneric\include;..\..\..\Source\M37xSWModules\include;..\..\..\Source\Motors;..\..\MotorControlM37x;..\..\..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Source\CMSIS\TX03_CMSIS;..\..\..\Source\Board\Powerboard
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
target Release - M374STK (ARM-ADS)
  device: TMPM374FWUG Toshiba
  cpu: as above
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_M374STK __KEIL__ __TMPM_374__
  c include: ..\..\..\Source\CMSIS\TX03_Periph_Driver\inc;..\..\..\Source\FreeRTOS\Source\include;..\..\..\Source\M37xHWGeneric\include;..\..\..\Source\M37xSWModules\include;..\..\..\Source\Motors;..\..\MotorControlM37x;..\..\..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Source\CMSIS\TX03_CMSIS;..\..\..\Source\Board\Baseboard\M374Baseboard\include;..\..\..\Source\Board\Powerboard
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
target Debug - M372STK (ARM-ADS)
  device: TMPM372FWUG Toshiba
  cpu: as above
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_M372STK __KEIL__ DEBUG __DBG_ITM __TMPM_372__
  c include: as above
  asm define: BOARD_M372STK
  asm include: ..\..\..\Source\Board\M372STK\include;..\..\..\Source\CMSIS\TX03_Periph_Driver\inc;..\..\..\Source\FreeRTOS\Source\include;..\..\..\Source\M37xHWGeneric\include;..\..\..\Source\M37xSWModules\include;..\..\..\Source\Motors;..\..\MotorControlM37x;..\..\..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Source\CMSIS\TX03_CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
target Release - M372STK (ARM-ADS)
  device: TMPM372FWUG Toshiba
  cpu: as above
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_M372STK __KEIL__  __TMPM_372__
  c include: as above
  asm define: BOARD_M372STK
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
target Debug - M37Sigma (ARM-ADS)
  device: TMPM373FWDUG Toshiba
  cpu: as above
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_M37SIGMA __KEIL__ DEBUG __DBG_ITM __TMPM_373__ USE_I2C_MASTER USE_RGB_LED USE_EXTERNAL_SPEED_CONTROL USE_RW_BOARD_SETTINGS
  c include: ..\..\..\Source\CMSIS\TX03_Periph_Driver\inc;..\..\..\Source\FreeRTOS\Source\include;..\..\..\Source\M37xHWGeneric\include;..\..\..\Source\M37xSWModules\include;..\..\..\Source\Motors;..\..\MotorControlM37x;..\..\..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Source\CMSIS\TX03_CMSIS;..\..\..\Source\Board\Powerboard;..\..\..\Source\Board\CPU_Board\M37Sigma\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
target Release - M37Sigma (ARM-ADS)
  device: TMPM373FWDUG Toshiba
  cpu: as above
  output: MotorControl
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: BOARD_M37SIGMA __KEIL__  __TMPM_373__ USE_I2C_MASTER USE_RGB_LED USE_EXTERNAL_SPEED_CONTROL USE_RW_BOARD_SETTINGS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
